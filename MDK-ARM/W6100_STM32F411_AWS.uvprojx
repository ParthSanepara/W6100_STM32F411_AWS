# Keil uVision project W6100_STM32F411_AWS.uvprojx, settings and files
target W6100_STM32F411_AWS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: W6100_STM32F411_AWS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F411xE MBEDTLS_CONFIG_FILE=<ssl_config.h>,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Libraries/io6Library_Driver/Ethernet;../Libraries/io6Library_Driver/Ethernet/W6100;../Libraries/io6Library_Driver/Internet/DHCP4;../Libraries/io6Library_Driver/Internet/DHCP6;../Libraries/io6Library_Driver/Internet/DNS;../Port;../Port/timer;../Port/mbedtls/inc;../Port/io6Library/inc;../Port/aws-iot-device-sdk-embedded-C/inc;../Libraries/mbedtls/include;../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreHTTP/source/include;../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreHTTP/source/interface;../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreHTTP/source/dependency/3rdparty/http_parser;../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreMQTT/source/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libraries/io6Library_Driver
    ../Libraries/io6Library_Driver/Ethernet/: wizchip_conf.c socket.c
    ../Libraries/io6Library_Driver/Ethernet/W6100/: w6100.c
    ../Libraries/io6Library_Driver/Application/loopback/: loopback.c
    ../Libraries/io6Library_Driver/Internet/DHCP4/: dhcpv4.c
    ../Libraries/io6Library_Driver/Internet/DNS/: dns.c
  group Port/io6Library
    ../Port/io6Library/src/: w6x00_spi.c
    ../Port/timer/: timer.c
  group Port/aws-iot-device-sdk-embedded-C
    ../Port/aws-iot-device-sdk-embedded-C/src/: ssl_transport_interface.c mqtt_transport_interface.c http_transport_interface.c timer_interface.c util.c dns_interface.c
  group mbedtls
    ../Libraries/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_driver_wrappers.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Libraries/aws-iot-device-sdk-embedded-C
    ../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
    ../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreHTTP/source/: core_http_client.c
    ../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
software components: CMSIS:CORE 4.3.0
